Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-04-25T10:45:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 25 10:45:37 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{BC7D453D-64DA-4A99-8F62-249CE5FA549C}\ifc * Database version: 5507 * Database creation date: Thu Apr 25 10:45:36 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 25 10:45:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 25 10:45:37 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 64432009 Washbasin faucet, 9/12 V, Bluetooth, 64432009:64432009 Washbasin faucet, 9/12 V, Bluetooth:353634
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 112 mm
Type - Electrical Engineering(Type) - Operating Voltage: 12 V
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 9 / 12 VDC; Electronic Parts: Autofocus sensor;Separate power supply
Type - General(Type) - Author: Convergo AB; BIMObjectName: 64432009; ConvergoRefNr: 0087-1905-0034-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_20_87_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_30_96_07; Version: 1; VersionDate: 10/04/2019
Type - Green Building Properties(Type) - Approval ACS: 15 ACC LY 337; Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 4057304009389; EMC Directive: EN 15091; EN Standard: EN 15091; Noise Class: I (ISO 3822); Protection Class: IP 55; URL ACS: http://static.hansa.com/ACS/64432009
Type - Identity Data(Type) - Catalog Drawing URL: http://static.hansa.com/catdrw/64432009; Class: Touchless, Bluetooth®; Dimension Drawing URL: http://static.hansa.com/dimdrw/64432009; FDV Document URL: http://www.hansa.com/datasheet/64432009/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/64432009; Group: Washbasin faucets; Manufacturer: Hansa; Market: AUT;BEL;DEU;ESP;FRA;INT;NLD; Model: 64432009 Washbasin faucet, 9/12 V, Bluetooth; Name_en: 64432009 Washbasin faucet, 9/12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 290 x 210 x 90; Package Weight: 2.032 kg; Product Code: 64432009; Product Datasheet: http://www.hansa.com/datasheet/64432009/en; Product Family: HANSAELECTRA; Product Image URL: http://static.hansa.com/image/64432009; Product URL: http://static.hansa.com/64432009; Type Name: 64432009 Washbasin faucet, 9/12 V, Bluetooth; Usage Group: Offices, personnel sanitary facilities;Pharmacies, Opticians, Dentists;Health centers & Child welfare clinics;Kindergartens;Institutional kitchens;Schools;Airports, Railway stations;Hotels, Restaurants, Café
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth);Convertible for cold and premixed-water; Aerator: Burglarproof; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection Size: G3/8; DN Size: DN15; Extensions: No pop-up waste included; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation and Maintenance: http://static.hansa.com/manual/64432009; Installation Type: Deck mounted; Intelligent After Flow Period: ON (OFF/ON); Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mounting Holes: 1 mounting hole; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 200000 Pa; Recognition Range: optimally preset; Spare Parts: http://static.hansa.com/sp/64432009; Spout Type: Fixed spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Public & Semi-public; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 64432009; Features: Touchless, Bluetooth®; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 64432009; Name: 64432009 Washbasin faucet, 9/12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 70x165x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Text(Type) - Technology Sales Arguments: Touch-free operation. Maximum comfort, maximum hygiene.
Pset_ManufacturerTypeInformation - ModelReference: 64432009; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 64432009 Washbasin faucet, 9/12 V, Bluetooth
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0523307 m2; Volume: 0.00197725 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 64432009: 64432009 Washbasin faucet, 9/12 V, Bluetooth; Family and Type: 64432009: 64432009 Washbasin faucet, 9/12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 64432009: 64432009 Washbasin faucet, 9/12 V, Bluetooth; Type Id: 64432009: 64432009 Washbasin faucet, 9/12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
